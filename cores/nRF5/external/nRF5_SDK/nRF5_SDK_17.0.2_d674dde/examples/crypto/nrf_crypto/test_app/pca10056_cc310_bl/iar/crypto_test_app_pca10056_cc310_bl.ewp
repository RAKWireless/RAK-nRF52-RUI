# IAR project crypto_test_app_pca10056_cc310_bl.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10056; BSP_DEFINES_ONLY; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52840_XXAA
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\crypto\backend\cc310; ..\..\..\..\..\..\components\libraries\crypto\backend\cc310_bl; ..\..\..\..\..\..\components\libraries\crypto\backend\cifra; ..\..\..\..\..\..\components\libraries\crypto\backend\mbedtls; ..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_hw; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_sw; ..\..\..\..\..\..\components\libraries\crypto\backend\oberon; ..\..\..\..\..\..\components\libraries\crypto\backend\optiga; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\stack_info; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..; ..\..\common_test; ..\..\test_cases; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\nrf_cc310\include; ..\..\..\..\..\..\external\nrf_cc310_bl\include; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: crypto_test_app_pca10056_cc310_bl.hex
  ILINK.IlinkOutputFile: crypto_test_app_pca10056_cc310_bl.out
  ILINK.IlinkIcfFile: crypto_test_app_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Test Cases
    ../../test_cases/: test_ecdsa.c test_sha.c test_vectors_ecdsa_random.c test_vectors_ecdsa_sign.c test_vectors_ecdsa_verify.c test_vectors_sha.c
  group nRF_Crypto backend CC310_BL
    ../../../../../../components/libraries/crypto/backend/cc310_bl/: cc310_bl_backend_ecc.c cc310_bl_backend_ecdsa.c cc310_bl_backend_hash.c cc310_bl_backend_init.c cc310_bl_backend_shared.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_rng.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_rng.c
  group nRF_Crypto
    ../../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group Application
    ../../common_test/: common_test.c
    ../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nrf_cc310_bl
    ../../../../../../external/nrf_cc310_bl/lib/cortex-m4/hard-float/short-wchar/: libnrf_cc310_bl_0.9.13.a
