# IAR project cli_libuarte_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\cli; ..\..\..\..\..\..\components\libraries\cli\libuarte; ..\..\..\..\..\..\components\libraries\cli\rtt; ..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\components\libraries\hardfault\nrf52; ..\..\..\..\..\..\components\libraries\libuarte; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fnmatch; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cli_libuarte_pca10040.hex
  ILINK.IlinkOutputFile: cli_libuarte_pca10040.out
  ILINK.IlinkIcfFile: cli_libuarte_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../external/fnmatch/: fnmatch.c
    ../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../components/libraries/cli/: nrf_cli.c
    ../../../../../../components/libraries/cli/libuarte/: nrf_cli_libuarte.c
    ../../../../../../components/libraries/cli/rtt/: nrf_cli_rtt.c
    ../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../components/libraries/libuarte/: nrf_libuarte_async.c nrf_libuarte_drv.c
    ../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Drivers
    ../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_ppi.c nrfx_rtc.c nrfx_timer.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group None
    ../../../../../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
