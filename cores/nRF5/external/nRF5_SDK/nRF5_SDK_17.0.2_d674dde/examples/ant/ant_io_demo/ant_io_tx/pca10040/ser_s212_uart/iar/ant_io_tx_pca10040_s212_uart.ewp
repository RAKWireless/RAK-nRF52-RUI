# IAR project ant_io_tx_pca10040_s212_uart.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; APP_TIMER_V2; APP_TIMER_V2_RTC1_ENABLED; BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; S212; SVCALL_AS_NORMAL_FUNCTION
  ICCARM.IExtraOptions: --diag_suppress Pe111
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\components\ant\ant_channel_config; ..\..\..\..\..\..\..\components\ant\ant_search_config; ..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\..\components\libraries\atomic_fifo; ..\..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\components\libraries\delay; ..\..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\..\components\libraries\hardfault; ..\..\..\..\..\..\..\components\libraries\hardfault\nrf52; ..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\..\components\libraries\mutex; ..\..\..\..\..\..\..\components\libraries\pwr_mgmt; ..\..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\..\components\libraries\sortlist; ..\..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\components\libraries\uart; ..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\components\serialization\application\codecs\ant\serializers; ..\..\..\..\..\..\..\components\serialization\application\hal; ..\..\..\..\..\..\..\components\serialization\application\transport; ..\..\..\..\..\..\..\components\serialization\common; ..\..\..\..\..\..\..\components\serialization\common\struct_ser\ant; ..\..\..\..\..\..\..\components\serialization\common\transport; ..\..\..\..\..\..\..\components\serialization\common\transport\ser_phy; ..\..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config; ..\..\..\..\..\..\..\components\softdevice\common; ..\..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\..\components\softdevice\s212\headers; ..\..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\..\components\softdevice\s212\headers\nrf52; ..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\..\external\segger_rtt; ..\..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ant_io_tx_pca10040_s212_uart.hex
  ILINK.IlinkOutputFile: ant_io_tx_pca10040_s212_uart.out
  ILINK.IlinkIcfFile: ant_io_tx_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../components/libraries/timer/: app_timer2.c drv_rtc.c
    ../../../../../../../components/libraries/uart/: app_uart.c
    ../../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../../../../components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Serialization
    ../../../../../../../components/serialization/application/codecs/ant/serializers/: ant_acknowledge_message_tx.c ant_active_search_sharing_cycles_get.c ant_active_search_sharing_cycles_set.c ant_adv_burst_config_set.c ant_broadcast_message_tx.c ant_capabilities_get.c ant_channel_assign.c ant_channel_close.c ant_channel_id_get.c ant_channel_id_set.c ant_channel_low_priority_rx_search_timeout_set.c ant_channel_open_with_offset.c ant_channel_period_get.c ant_channel_period_set.c ant_channel_radio_freq_get.c ant_channel_radio_freq_set.c ant_channel_radio_tx_power_set.c ant_channel_rx_search_timeout_set.c ant_channel_status_get.c ant_channel_unassign.c ant_coex_config_get.c ant_coex_config_set.c ant_crypto_channel_enable.c ant_crypto_info_get.c ant_crypto_info_set.c ant_crypto_key_set.c ant_cw_test_mode.c ant_cw_test_mode_init.c ant_enable.c ant_event.c ant_id_list_add.c ant_id_list_config.c ant_lib_config_clear.c ant_lib_config_get.c ant_lib_config_set.c ant_network_address_set.c ant_prox_search_set.c ant_rx_scan_mode_start.c ant_search_channel_priority_set.c ant_search_waveform_set.c ant_stack_reset.c ant_version_get.c
    ../../../../../../../components/serialization/common/struct_ser/ant/: ant_struct_serialization.c
    ../../../../../../../components/serialization/application/codecs/ant/middleware/: app_mw_ant.c
    ../../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../../components/serialization/application/hal/: ser_app_hal_nrf5x.c ser_app_power_system_off.c
    ../../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_uart.c
    ../../../../../../../components/serialization/application/transport/: ser_sd_transport.c ser_softdevice_handler.c
  group nRF_Drivers
    ../../../../../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../../../../../../modules/nrfx/hal/: nrf_nvmc.c
    ../../../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
    ../../../../../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../../../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c
    ../../../../../../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_ANT
    ../../../../../../../components/ant/ant_channel_config/: ant_channel_config.c
    ../../../../../../../components/ant/ant_search_config/: ant_search_config.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c
  group Application
    ../../../: ant_io_tx.c main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_printf.c
  group None
    ../../../../../../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ant.c
